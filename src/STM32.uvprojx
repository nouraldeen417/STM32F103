# Keil uVision project STM32.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C4 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00001800) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\HAL;.\lip;.\MCAL\DIO;.\MCAL\SYSTICK;.\MCAL\NVIC
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group Source Group 1
    ./: main.c
    ./MCAL/DIO/: DIO_program.c
    ./MCAL/NVIC/: NVIC_program.c
    ./MCAL/SYSTICK/: SYSTICK_program.c
    ./MCAL/PORT/: PORT_program.c
    ./MCAL/EXTI/: EXTI_program.c
    ./MCAL/TIMERS/: TIMERS_program.c
    ./MCAL/RCC/: RCC_Program.c
    ./MCAL/RTC/: RTC_Program.c
    ./HAL/LCD/: LCD_program.c
    ./MCAL/ADC/: ADC_program.c
    ./MCAL/SPI/: SPI_progrm.c
    ./MCAL/USART/: USART_program.c
    ./MCAL/DMA/: DMA_program.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
